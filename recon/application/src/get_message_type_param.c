../../named/get_message_type_param.c