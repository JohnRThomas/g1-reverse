../../named/pairing_complete.c