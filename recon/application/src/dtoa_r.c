../../named/dtoa_r.c