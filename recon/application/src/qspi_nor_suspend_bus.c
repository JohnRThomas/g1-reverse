../../named/qspi_nor_suspend_bus.c