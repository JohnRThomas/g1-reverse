../../named/FUN_00024678.c