../../named/FUN_00023eec.c