../../named/set_brightness_lum_base.c