../../named/debug_print_hex_dump.c