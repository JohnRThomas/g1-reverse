../../named/init_dashboard_info.c