../../named/check_work_mode.c