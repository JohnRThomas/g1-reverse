../../named/demo_image_get_position.c