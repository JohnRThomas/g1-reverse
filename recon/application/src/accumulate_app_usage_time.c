../../named/accumulate_app_usage_time.c