../../named/check_disp_onboarding.c