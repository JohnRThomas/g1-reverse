../../named/register_events.c