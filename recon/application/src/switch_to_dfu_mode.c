../../named/switch_to_dfu_mode.c