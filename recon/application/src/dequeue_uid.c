../../named/dequeue_uid.c