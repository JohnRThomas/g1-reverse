../../named/sc_restore.c