../../named/reset_esb_sync_state.c