../../named/load_burial_point.c