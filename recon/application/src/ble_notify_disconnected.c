../../named/ble_notify_disconnected.c