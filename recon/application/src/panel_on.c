../../named/panel_on.c