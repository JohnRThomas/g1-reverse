../../named/ipc_log_forward.c