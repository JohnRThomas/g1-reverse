../../named/panel_level_calc_cached.c