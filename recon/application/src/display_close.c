../../named/display_close.c