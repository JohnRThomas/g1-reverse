../../named/app_codec_lc3_test.c