../../named/opt3001_reg_read.c