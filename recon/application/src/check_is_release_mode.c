../../named/check_is_release_mode.c