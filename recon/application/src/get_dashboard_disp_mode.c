../../named/get_dashboard_disp_mode.c