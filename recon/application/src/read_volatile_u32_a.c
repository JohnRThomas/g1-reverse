../../named/read_volatile_u32_a.c