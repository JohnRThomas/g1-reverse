../../named/ancs_ctx_init.c