../../named/get_synced_clock_time.c