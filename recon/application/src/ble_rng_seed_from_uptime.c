../../named/ble_rng_seed_from_uptime.c