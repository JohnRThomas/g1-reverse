../../named/strtod.c