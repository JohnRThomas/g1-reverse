../../named/nrf53_sync_rtc_init.c