../../named/update_imu_trigger_status.c