../../named/send_pairing_rsp.c