../../named/st25dv_write_reg_pair.c