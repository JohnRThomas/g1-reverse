../../named/ipc_ept_op_b_locked_retry.c