../../named/get_demo_image_source.c