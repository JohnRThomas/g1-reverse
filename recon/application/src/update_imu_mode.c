../../named/update_imu_mode.c