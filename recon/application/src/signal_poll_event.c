../../named/signal_poll_event.c