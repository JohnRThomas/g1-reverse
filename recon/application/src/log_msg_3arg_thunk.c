../../named/log_msg_3arg_thunk.c