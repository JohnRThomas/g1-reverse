../../named/uarte_blocking_transfer.c