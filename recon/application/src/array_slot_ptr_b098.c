../../named/array_slot_ptr_b098.c