../../named/ext_flash_sync_noop.c