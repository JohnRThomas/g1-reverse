../../named/pow5mult.c