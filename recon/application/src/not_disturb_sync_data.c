../../named/not_disturb_sync_data.c