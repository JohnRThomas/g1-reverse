../../named/FUN_0004d6ec.c