../../named/get_ui_mode_flag_byte1.c