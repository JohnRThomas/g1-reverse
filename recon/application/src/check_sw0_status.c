../../named/check_sw0_status.c