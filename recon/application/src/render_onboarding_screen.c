../../named/render_onboarding_screen.c