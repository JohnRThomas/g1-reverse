../../named/safe_memcpy_checked.c