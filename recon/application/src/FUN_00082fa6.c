../../named/FUN_00082fa6.c