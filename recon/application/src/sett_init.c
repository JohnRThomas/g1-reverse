../../named/sett_init.c