../../named/opt_list_total_len.c