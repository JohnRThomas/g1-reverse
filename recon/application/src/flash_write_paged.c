../../named/flash_write_paged.c