../../named/get_lux_info.c