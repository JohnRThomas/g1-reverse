../../named/clock_control_nrf_on.c