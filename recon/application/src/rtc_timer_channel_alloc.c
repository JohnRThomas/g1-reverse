../../named/rtc_timer_channel_alloc.c