../../named/is_tx_ready.c