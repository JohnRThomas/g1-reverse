../../named/qspi_nor_configure.c