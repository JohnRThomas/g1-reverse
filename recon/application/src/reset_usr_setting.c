../../named/reset_usr_setting.c