../../named/bt_addr_le_copy.c