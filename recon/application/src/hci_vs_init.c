../../named/hci_vs_init.c