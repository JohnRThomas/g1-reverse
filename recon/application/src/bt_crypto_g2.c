../../named/bt_crypto_g2.c