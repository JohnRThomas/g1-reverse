../../named/kmutex_dlist_init.c