../../named/fb_blit_rows_copy.c