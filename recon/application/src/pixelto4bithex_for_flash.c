../../named/pixelto4bithex_for_flash.c