../../named/log_forward_zero_arg.c