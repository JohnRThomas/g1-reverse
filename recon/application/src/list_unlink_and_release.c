../../named/list_unlink_and_release.c