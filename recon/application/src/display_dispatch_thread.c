../../named/display_dispatch_thread.c