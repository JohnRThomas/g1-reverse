../../named/ipc_ept_op_c_locked_retry.c