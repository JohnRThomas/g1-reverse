../../named/set_box_link_state_flag.c