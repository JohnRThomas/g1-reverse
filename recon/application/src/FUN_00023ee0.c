../../named/FUN_00023ee0.c