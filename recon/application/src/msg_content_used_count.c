../../named/msg_content_used_count.c