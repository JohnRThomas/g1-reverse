../../named/get_message_pending_state.c