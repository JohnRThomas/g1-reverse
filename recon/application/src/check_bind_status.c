../../named/check_bind_status.c