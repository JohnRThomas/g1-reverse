../../named/get_projector_controller.c