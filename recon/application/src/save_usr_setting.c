../../named/save_usr_setting.c