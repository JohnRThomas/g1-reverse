../../named/get_message_pool_index.c