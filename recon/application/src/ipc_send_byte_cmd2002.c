../../named/ipc_send_byte_cmd2002.c