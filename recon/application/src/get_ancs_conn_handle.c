../../named/get_ancs_conn_handle.c