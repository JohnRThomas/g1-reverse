../../named/delVoiceBlock.c