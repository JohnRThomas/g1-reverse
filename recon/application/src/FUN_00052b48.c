../../named/FUN_00052b48.c