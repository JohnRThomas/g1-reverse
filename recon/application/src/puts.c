../../named/puts.c