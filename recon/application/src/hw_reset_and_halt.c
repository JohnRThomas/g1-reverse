../../named/hw_reset_and_halt.c