../../named/is_battery_critical.c