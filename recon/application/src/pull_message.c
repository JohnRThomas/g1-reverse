../../named/pull_message.c