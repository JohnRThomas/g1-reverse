../../named/init_nfc_comm.c