../../named/push_message.c