../../named/FUN_00026338.c