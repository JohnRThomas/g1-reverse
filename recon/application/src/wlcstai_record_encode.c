../../named/wlcstai_record_encode.c