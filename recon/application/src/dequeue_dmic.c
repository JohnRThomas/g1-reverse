../../named/dequeue_dmic.c