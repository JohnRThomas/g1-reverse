../../named/set_random_address.c