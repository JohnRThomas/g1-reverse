../../named/global_ipc_service_send.c