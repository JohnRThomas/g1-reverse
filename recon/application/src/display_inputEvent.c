../../named/display_inputEvent.c