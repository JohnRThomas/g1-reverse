../../named/spi_read_id.c