../../named/FUN_00059c48.c