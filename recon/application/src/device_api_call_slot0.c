../../named/device_api_call_slot0.c