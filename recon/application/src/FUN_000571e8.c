../../named/FUN_000571e8.c