../../named/hci_read_static_addresses.c