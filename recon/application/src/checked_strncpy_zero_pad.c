../../named/checked_strncpy_zero_pad.c