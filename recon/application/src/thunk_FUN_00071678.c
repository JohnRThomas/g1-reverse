../../named/thunk_FUN_00071678.c