../../named/bt_addr_le_copy_80fc4.c