../../named/FUN_00078598.c