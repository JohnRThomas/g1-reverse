../../named/ancs_disconnected.c