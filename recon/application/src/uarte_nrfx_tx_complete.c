../../named/uarte_nrfx_tx_complete.c