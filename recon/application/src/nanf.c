../../named/nanf.c