../../named/check_bonded_addr.c