../../named/read_name.c