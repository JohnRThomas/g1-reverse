../../named/hci_vs_setup_stub.c