../../named/sys_memcpy_swap.c