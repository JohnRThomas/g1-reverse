../../named/nrf_rtc_set_alarm_channel.c