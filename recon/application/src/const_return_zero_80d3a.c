../../named/const_return_zero_80d3a.c