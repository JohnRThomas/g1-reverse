../../named/FUN_00026624.c