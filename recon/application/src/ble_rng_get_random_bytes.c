../../named/ble_rng_get_random_bytes.c