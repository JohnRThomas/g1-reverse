../../named/gui_bmp_bitmap_draw_ex.c