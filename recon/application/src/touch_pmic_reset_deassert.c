../../named/touch_pmic_reset_deassert.c