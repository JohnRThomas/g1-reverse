../../named/stop_some_timer.c