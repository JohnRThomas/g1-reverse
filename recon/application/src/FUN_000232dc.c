../../named/FUN_000232dc.c