../../named/FUN_00067d84.c