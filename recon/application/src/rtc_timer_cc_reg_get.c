../../named/rtc_timer_cc_reg_get.c