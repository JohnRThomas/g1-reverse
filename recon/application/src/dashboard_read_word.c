../../named/dashboard_read_word.c