../../named/FUN_00024d50.c