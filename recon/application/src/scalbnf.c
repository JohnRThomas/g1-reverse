../../named/scalbnf.c