../../named/ptr_read_u32.c