../../named/clear_transfer_conn_slot.c