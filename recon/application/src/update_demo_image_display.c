../../named/update_demo_image_display.c