../../named/some_module_sem_init.c