../../named/attr_store_set.c