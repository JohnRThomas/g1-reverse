../../named/gui_string_draw.c