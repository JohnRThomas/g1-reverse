../../named/fuel_gauge_unlock.c