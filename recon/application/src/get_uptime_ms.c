../../named/get_uptime_ms.c