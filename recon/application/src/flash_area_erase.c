../../named/flash_area_erase.c