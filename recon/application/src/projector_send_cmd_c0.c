../../named/projector_send_cmd_c0.c