../../named/get_static_ctx_ptr.c