../../named/ble_conn_lookup_masked.c