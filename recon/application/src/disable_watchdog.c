../../named/disable_watchdog.c