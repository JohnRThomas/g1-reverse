../../named/onboarding_sync_data.c