../../named/ringbuf_flush_chunk.c