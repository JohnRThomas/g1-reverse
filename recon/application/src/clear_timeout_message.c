../../named/clear_timeout_message.c