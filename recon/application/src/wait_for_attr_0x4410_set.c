../../named/wait_for_attr_0x4410_set.c