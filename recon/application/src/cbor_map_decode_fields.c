../../named/cbor_map_decode_fields.c