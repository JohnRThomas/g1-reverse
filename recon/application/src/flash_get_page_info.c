../../named/flash_get_page_info.c