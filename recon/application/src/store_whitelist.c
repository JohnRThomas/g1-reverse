../../named/store_whitelist.c