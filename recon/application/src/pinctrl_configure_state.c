../../named/pinctrl_configure_state.c