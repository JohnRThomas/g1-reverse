../../named/uarte_nrfx_tx_start.c