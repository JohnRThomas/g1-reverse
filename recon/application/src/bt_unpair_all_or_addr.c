../../named/bt_unpair_all_or_addr.c