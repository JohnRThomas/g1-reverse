../../named/FUN_00059dec.c