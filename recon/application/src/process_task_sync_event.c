../../named/process_task_sync_event.c