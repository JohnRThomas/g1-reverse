../../named/global_system_resume.c