../../named/set_device_sn_info.c