../../named/compute_day_of_week.c