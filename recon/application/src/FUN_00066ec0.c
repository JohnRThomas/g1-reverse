../../named/FUN_00066ec0.c