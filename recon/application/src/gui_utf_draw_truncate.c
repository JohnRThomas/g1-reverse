../../named/gui_utf_draw_truncate.c