../../named/pow.c