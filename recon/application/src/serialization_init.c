../../named/serialization_init.c