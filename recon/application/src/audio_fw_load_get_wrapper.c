../../named/audio_fw_load_get_wrapper.c