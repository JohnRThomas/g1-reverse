../../named/start_aging_mode_thread.c