../../named/event_record_init.c