../../named/spawn_display_thread.c