../../named/send_response_data_to_ble.c