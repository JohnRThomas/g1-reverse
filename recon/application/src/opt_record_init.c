../../named/opt_record_init.c