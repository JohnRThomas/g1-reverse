../../named/get_app_whitelist_buffer.c