../../named/request_ancs_attr_ext.c