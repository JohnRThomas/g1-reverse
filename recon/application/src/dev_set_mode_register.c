../../named/dev_set_mode_register.c