../../named/dev_read_status_bit_reg34.c