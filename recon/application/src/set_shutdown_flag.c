../../named/set_shutdown_flag.c