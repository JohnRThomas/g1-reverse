../../named/thunk_FUN_00086384.c