../../named/FUN_00084cb0.c