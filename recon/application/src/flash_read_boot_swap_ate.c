../../named/flash_read_boot_swap_ate.c