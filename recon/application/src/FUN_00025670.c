../../named/FUN_00025670.c