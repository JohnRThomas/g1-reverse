../../named/array_max_skip_nan_b.c