../../named/FUN_00078bf8.c