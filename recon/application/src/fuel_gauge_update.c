../../named/fuel_gauge_update.c