../../named/fill_record_type8.c