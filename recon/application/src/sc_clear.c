../../named/sc_clear.c