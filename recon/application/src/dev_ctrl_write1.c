../../named/dev_ctrl_write1.c