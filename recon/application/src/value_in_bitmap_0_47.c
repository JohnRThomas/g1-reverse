../../named/value_in_bitmap_0_47.c