../../named/bt_dev_get.c