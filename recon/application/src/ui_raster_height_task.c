../../named/ui_raster_height_task.c