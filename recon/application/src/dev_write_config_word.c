../../named/dev_write_config_word.c