../../named/get_active_message_count.c