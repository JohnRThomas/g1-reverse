../../named/set_test_mode.c