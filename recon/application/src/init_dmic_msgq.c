../../named/init_dmic_msgq.c