../../named/dump_template_gyro_info.c