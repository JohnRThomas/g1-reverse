../../named/update_display_status.c