../../named/cleanAppLanguageInfo.c