../../named/hci_cmd_alloc_failure_log.c