../../named/FUN_00066d78.c