../../named/sys_heap_aligned_alloc.c