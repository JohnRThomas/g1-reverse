../../named/FUN_00025ecc.c