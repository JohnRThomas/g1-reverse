../../named/get_adv_channel_map.c