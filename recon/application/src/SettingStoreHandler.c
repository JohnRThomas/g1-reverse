../../named/SettingStoreHandler.c