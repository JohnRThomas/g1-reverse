../../named/discovery_callback.c