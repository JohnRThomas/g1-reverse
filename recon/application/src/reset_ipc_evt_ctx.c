../../named/reset_ipc_evt_ctx.c