../../named/FUN_00066d1c.c