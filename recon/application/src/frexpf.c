../../named/frexpf.c