../../named/opt_node_header_len.c