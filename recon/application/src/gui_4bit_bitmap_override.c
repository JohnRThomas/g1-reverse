../../named/gui_4bit_bitmap_override.c