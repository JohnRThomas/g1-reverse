../../named/FUN_0007c6a0.c