../../named/FUN_00060a5c.c