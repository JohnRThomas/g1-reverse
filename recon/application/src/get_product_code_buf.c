../../named/get_product_code_buf.c