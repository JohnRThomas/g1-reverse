../../named/sys_notify_finalize.c