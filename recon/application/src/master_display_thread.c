../../named/master_display_thread.c