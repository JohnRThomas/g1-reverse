../../named/thread_entry_no_return.c