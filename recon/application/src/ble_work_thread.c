../../named/ble_work_thread.c