../../named/mic_transm_thread.c