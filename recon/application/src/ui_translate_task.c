../../named/ui_translate_task.c