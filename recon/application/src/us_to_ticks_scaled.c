../../named/us_to_ticks_scaled.c