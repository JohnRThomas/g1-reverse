../../named/msg_queue_init.c