../../named/qspi_nor_acquire.c