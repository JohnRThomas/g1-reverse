../../named/svc_attr_memory_release.c