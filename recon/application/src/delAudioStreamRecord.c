../../named/delAudioStreamRecord.c