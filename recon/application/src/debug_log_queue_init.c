../../named/debug_log_queue_init.c