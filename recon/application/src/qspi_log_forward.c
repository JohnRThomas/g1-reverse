../../named/qspi_log_forward.c