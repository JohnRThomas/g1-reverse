../../named/display_MasterSendClose.c