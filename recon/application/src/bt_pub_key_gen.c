../../named/bt_pub_key_gen.c