../../named/flash_nrf_erase.c