../../named/init_analytics_settings.c