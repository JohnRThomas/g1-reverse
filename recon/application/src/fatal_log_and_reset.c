../../named/fatal_log_and_reset.c