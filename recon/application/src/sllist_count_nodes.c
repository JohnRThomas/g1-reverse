../../named/sllist_count_nodes.c