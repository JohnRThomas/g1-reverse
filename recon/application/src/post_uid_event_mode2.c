../../named/post_uid_event_mode2.c