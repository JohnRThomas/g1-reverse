../../named/log_msg_process.c