../../named/FUN_00023ef8.c