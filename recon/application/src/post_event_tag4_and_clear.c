../../named/post_event_tag4_and_clear.c