../../named/active_mode_shutdown.c