../../named/ancs_connected.c