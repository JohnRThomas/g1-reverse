../../named/mem_find_byte.c