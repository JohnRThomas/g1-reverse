../../named/attr_store_init_sequence.c