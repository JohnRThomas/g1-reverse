../../named/sc_restore_rsp.c