../../named/sem_init_zero.c