../../named/stopAudioStreamRecord.c