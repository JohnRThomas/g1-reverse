../../named/bt_ancs_cp_write_callback.c