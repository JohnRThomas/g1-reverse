../../named/fuel_gauge_lock.c