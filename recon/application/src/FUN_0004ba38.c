../../named/FUN_0004ba38.c