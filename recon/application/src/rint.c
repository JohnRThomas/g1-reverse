../../named/rint.c