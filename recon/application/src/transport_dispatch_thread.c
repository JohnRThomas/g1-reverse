../../named/transport_dispatch_thread.c