../../named/activate_foreach_backend.c