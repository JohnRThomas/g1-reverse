../../named/FUN_00032fdc.c