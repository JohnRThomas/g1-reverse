../../named/is_system_idle_ready.c