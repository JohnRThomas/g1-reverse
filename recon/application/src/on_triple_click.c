../../named/on_triple_click.c