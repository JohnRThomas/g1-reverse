../../named/ancs_discover_ctx_clear.c