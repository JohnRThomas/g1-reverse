../../named/arch_irq_priority_set.c