../../named/finite.c