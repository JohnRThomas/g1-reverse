../../named/FUN_0007d1d6.c