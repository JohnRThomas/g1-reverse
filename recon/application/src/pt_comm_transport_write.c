../../named/pt_comm_transport_write.c