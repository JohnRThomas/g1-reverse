../../named/FUN_000232c0.c