../../named/qspi_nor_pm_action.c