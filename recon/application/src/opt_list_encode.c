../../named/opt_list_encode.c