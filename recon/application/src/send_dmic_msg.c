../../named/send_dmic_msg.c