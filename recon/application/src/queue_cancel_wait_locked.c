../../named/queue_cancel_wait_locked.c