../../named/app_event_manager_submit.c