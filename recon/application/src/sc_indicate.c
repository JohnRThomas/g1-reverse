../../named/sc_indicate.c