../../named/cal_panel_canvas_coord.c