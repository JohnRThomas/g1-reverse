../../named/FUN_00067938.c