../../named/local_store_write.c