../../named/attr_store_get.c