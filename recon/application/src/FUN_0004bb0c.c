../../named/FUN_0004bb0c.c