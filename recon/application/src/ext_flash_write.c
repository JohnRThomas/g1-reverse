../../named/ext_flash_write.c