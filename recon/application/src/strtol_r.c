../../named/strtol_r.c