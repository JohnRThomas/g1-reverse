../../named/legacy_adv_stop_cleanup.c