../../named/pend_locked.c