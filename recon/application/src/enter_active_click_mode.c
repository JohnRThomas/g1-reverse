../../named/enter_active_click_mode.c