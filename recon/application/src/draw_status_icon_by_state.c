../../named/draw_status_icon_by_state.c