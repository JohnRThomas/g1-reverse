../../named/spec_ble_command_hook.c