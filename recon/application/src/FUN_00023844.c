../../named/FUN_00023844.c