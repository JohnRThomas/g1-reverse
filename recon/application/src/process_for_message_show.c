../../named/process_for_message_show.c