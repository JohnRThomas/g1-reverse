../../named/atomic_or_bit1.c