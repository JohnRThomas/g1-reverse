../../named/sc_save.c