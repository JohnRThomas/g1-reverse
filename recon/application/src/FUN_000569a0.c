../../named/FUN_000569a0.c