../../named/arch_swap.c