../../named/get_click_dispatch_flag.c