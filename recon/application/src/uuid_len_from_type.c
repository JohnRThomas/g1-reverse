../../named/uuid_len_from_type.c