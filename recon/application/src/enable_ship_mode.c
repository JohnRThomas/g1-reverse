../../named/enable_ship_mode.c