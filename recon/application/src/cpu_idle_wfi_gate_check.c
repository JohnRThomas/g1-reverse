../../named/cpu_idle_wfi_gate_check.c