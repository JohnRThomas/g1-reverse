../../named/audio_codec_set_gain_ch0.c