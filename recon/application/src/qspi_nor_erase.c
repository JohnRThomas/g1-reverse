../../named/qspi_nor_erase.c