../../named/dev_write_channel_mode.c