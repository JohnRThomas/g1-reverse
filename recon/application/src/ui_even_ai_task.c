../../named/ui_even_ai_task.c