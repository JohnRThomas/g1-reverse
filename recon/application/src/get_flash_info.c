../../named/get_flash_info.c