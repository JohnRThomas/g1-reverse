../../named/FUN_00031bd8.c