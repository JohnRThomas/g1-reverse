../../named/is_msg_expiration.c