../../named/attr_configure_pair.c