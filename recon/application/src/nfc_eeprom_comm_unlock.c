../../named/nfc_eeprom_comm_unlock.c