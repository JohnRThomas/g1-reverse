../../named/projector_fill_and_sync.c