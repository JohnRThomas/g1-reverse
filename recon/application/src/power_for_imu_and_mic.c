../../named/power_for_imu_and_mic.c