../../named/display_dev_reg_config.c