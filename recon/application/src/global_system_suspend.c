../../named/global_system_suspend.c