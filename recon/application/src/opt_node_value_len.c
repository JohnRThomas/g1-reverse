../../named/opt_node_value_len.c