../../named/clear_legacy_adv_state.c