../../named/uint32_to_little_endian.c