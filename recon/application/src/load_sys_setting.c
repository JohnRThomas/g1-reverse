../../named/load_sys_setting.c