../../named/get_system_unix_time.c