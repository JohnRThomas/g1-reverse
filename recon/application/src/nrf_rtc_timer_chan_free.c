../../named/nrf_rtc_timer_chan_free.c