../../named/calc_flash_crc.c