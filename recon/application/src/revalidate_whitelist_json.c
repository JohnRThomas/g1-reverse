../../named/revalidate_whitelist_json.c