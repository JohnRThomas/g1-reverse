../../named/sllist_find_by_name_ci.c