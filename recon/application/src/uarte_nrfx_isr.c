../../named/uarte_nrfx_isr.c