../../named/FUN_00049acc.c