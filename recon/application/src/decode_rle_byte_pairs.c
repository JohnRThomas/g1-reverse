../../named/decode_rle_byte_pairs.c