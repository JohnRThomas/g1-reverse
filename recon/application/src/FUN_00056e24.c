../../named/FUN_00056e24.c