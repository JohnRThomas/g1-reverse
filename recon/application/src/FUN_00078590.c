../../named/FUN_00078590.c