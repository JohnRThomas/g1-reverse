../../named/uptime_ticks_get.c