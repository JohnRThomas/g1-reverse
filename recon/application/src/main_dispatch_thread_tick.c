../../named/main_dispatch_thread_tick.c