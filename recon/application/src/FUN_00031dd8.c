../../named/FUN_00031dd8.c