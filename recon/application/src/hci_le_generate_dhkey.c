../../named/hci_le_generate_dhkey.c