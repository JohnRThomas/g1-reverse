../../named/FUN_00032b24.c