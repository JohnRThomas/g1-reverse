../../named/get_audio_msgq_used_count.c