../../named/snprintf_engine_bounded.c