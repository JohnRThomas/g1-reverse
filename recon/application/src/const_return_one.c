../../named/const_return_one.c