../../named/panel_off.c