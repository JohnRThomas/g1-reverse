../../named/init_watchdog.c