../../named/get_last_standby_event_id.c