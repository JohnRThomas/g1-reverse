../../named/qspi_nor_write.c