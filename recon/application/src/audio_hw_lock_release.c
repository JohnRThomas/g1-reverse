../../named/audio_hw_lock_release.c