../../named/emit_u8_value_via_vtable.c