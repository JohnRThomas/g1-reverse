../../named/dev_write_bits5_diff.c