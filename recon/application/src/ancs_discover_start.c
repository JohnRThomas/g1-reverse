../../named/ancs_discover_start.c