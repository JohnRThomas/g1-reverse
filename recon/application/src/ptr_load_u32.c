../../named/ptr_load_u32.c