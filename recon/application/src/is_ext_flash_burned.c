../../named/is_ext_flash_burned.c