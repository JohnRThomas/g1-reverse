../../named/reset_all_static_info.c