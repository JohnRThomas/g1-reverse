../../named/change_work_mode_to.c