../../named/set_display_page_index.c