../../named/getDelayExitValue.c