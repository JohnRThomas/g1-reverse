../../named/audio_codec_set_gain_ch1.c