../../named/ble_conn_set_state.c