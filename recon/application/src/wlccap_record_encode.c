../../named/wlccap_record_encode.c