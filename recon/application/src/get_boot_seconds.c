../../named/get_boot_seconds.c