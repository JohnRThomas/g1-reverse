../../named/nullsub_3.c