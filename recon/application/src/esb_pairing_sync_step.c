../../named/esb_pairing_sync_step.c