../../named/set_misc_286c_value.c