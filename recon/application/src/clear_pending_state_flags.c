../../named/clear_pending_state_flags.c