../../named/getQuickNoteDataFromFlash.c