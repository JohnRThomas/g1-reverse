../../named/now_has_persist_task.c