../../named/draw_message.c