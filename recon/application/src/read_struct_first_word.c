../../named/read_struct_first_word.c