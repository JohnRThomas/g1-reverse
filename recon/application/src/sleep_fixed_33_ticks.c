../../named/sleep_fixed_33_ticks.c