../../named/signal_persist_task_event.c