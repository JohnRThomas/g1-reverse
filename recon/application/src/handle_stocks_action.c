../../named/handle_stocks_action.c