../../named/log_output_flush_noop.c