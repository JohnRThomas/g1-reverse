../../named/us_to_ticks_scaled_v2.c