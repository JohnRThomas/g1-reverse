../../named/battery_soc_from_curve.c