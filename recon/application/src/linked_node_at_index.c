../../named/linked_node_at_index.c