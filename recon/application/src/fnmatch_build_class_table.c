../../named/fnmatch_build_class_table.c