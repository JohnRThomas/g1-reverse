../../named/spline_interp_pair_2out.c