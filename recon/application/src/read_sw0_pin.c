../../named/read_sw0_pin.c