../../named/gpio_set_pin1_dt_wrapper.c