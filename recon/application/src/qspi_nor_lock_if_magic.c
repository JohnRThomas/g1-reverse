../../named/qspi_nor_lock_if_magic.c