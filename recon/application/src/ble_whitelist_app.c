../../named/ble_whitelist_app.c