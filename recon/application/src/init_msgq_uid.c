../../named/init_msgq_uid.c