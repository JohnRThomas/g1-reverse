../../named/parse_receiver_pack_pkcs7.c