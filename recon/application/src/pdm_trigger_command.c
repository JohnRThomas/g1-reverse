../../named/pdm_trigger_command.c