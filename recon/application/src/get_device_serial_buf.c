../../named/get_device_serial_buf.c