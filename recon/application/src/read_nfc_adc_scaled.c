../../named/read_nfc_adc_scaled.c