../../named/spi_master_init.c