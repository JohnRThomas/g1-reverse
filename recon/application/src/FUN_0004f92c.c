../../named/FUN_0004f92c.c