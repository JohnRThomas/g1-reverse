../../named/bt_set_name_internal.c