../../named/FUN_000569ec.c