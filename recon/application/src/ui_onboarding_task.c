../../named/ui_onboarding_task.c