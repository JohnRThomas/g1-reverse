../../named/g1_nrfx_clock_stop_lfclk.c