../../named/fortify_chk_fail.c