../../named/dev_write_reg3.c