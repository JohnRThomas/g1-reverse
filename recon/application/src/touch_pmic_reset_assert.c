../../named/touch_pmic_reset_assert.c