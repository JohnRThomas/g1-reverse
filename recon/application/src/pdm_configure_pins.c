../../named/pdm_configure_pins.c