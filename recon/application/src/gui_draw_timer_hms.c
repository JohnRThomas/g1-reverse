../../named/gui_draw_timer_hms.c