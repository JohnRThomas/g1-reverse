../../named/getNewsIndex.c