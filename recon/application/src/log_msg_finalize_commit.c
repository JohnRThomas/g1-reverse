../../named/log_msg_finalize_commit.c