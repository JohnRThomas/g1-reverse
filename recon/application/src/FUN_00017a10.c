../../named/FUN_00017a10.c