../../named/st25dv_read_area_size.c