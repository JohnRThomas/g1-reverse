../../named/bt_dev_show_info.c