../../named/update_temp_task_status.c