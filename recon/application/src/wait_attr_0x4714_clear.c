../../named/wait_attr_0x4714_clear.c