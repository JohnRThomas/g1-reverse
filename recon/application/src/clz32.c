../../named/clz32.c