../../named/opt_record_decode.c