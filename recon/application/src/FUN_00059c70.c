../../named/FUN_00059c70.c