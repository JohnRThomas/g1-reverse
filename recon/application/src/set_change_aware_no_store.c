../../named/set_change_aware_no_store.c