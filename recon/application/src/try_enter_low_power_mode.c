../../named/try_enter_low_power_mode.c