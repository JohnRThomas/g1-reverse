../../named/smakebuf_r.c