../../named/sc_set.c