../../named/gui_set_active_canvas.c