../../named/find_sc_cfg_59b94.c