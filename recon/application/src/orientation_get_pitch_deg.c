../../named/orientation_get_pitch_deg.c