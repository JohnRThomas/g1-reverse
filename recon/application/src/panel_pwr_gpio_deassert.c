../../named/panel_pwr_gpio_deassert.c