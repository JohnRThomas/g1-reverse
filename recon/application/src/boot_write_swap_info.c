../../named/boot_write_swap_info.c