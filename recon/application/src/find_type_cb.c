../../named/find_type_cb.c