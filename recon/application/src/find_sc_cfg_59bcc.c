../../named/find_sc_cfg_59bcc.c