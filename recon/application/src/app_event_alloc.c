../../named/app_event_alloc.c