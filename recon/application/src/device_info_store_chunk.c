../../named/device_info_store_chunk.c