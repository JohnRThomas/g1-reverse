../../named/flash_region_is_erased.c