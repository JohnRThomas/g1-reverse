../../named/dev_ctrl_write2.c