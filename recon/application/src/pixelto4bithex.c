../../named/pixelto4bithex.c