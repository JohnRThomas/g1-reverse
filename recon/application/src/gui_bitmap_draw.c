../../named/gui_bitmap_draw.c