../../named/fabs.c