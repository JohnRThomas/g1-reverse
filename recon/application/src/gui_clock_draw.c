../../named/gui_clock_draw.c