../../named/get_dmic_msgq_count.c