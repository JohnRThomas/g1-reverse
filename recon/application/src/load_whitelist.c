../../named/load_whitelist.c