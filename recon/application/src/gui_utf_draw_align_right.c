../../named/gui_utf_draw_align_right.c