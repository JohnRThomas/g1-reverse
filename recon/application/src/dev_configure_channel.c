../../named/dev_configure_channel.c