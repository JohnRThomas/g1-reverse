../../named/auth_cancel.c