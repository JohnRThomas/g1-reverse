../../named/indicate_sc_cb.c