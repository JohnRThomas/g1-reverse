../../named/FUN_00067600.c