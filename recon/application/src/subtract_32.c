../../named/subtract_32.c