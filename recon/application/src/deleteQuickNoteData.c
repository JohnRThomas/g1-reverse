../../named/deleteQuickNoteData.c