../../named/cleanStocksIndex.c