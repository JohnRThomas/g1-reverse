../../named/setDelayExitValue.c