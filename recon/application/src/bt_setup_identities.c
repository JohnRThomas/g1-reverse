../../named/bt_setup_identities.c