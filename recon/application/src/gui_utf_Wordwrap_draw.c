../../named/gui_utf_Wordwrap_draw.c