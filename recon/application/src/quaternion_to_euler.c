../../named/quaternion_to_euler.c