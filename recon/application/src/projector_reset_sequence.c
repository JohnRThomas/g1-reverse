../../named/projector_reset_sequence.c