../../named/flash_write_padded_entry.c