../../named/value_encode_len.c