../../named/display_thread_handler.c