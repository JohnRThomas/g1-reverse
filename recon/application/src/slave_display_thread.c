../../named/slave_display_thread.c