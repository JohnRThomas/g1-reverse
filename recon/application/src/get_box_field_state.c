../../named/get_box_field_state.c