../../named/spline_interp_3pt.c