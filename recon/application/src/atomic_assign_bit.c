../../named/atomic_assign_bit.c