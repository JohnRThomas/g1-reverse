../../named/mem_read_validated.c