../../named/FUN_00047ab8.c