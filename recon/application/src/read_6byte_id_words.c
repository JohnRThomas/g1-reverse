../../named/read_6byte_id_words.c