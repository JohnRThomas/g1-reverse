../../named/ancs_gatt_client_cb_set.c