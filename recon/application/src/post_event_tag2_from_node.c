../../named/post_event_tag2_from_node.c