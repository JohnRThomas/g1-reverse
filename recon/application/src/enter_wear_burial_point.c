../../named/enter_wear_burial_point.c