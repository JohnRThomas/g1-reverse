../../named/projector_send_command.c