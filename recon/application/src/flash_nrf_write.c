../../named/flash_nrf_write.c