../../named/poll_signal_event_locked.c