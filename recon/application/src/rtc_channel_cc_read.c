../../named/rtc_channel_cc_read.c