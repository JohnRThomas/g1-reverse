../../named/verify_image_checksum.c