../../named/ext_flash_read.c