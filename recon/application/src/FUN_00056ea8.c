../../named/FUN_00056ea8.c