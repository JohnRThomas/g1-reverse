../../named/ble_conn_pool_alloc.c