../../named/dispatch_via_object_index.c