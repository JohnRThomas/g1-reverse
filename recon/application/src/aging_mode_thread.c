../../named/aging_mode_thread.c