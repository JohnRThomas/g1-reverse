../../named/start_ancs_work_thread.c