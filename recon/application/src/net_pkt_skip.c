../../named/net_pkt_skip.c