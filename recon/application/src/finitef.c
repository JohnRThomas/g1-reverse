../../named/finitef.c