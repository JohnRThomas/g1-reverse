../../named/channel_pull_one_byte.c