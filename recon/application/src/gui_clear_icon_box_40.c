../../named/gui_clear_icon_box_40.c