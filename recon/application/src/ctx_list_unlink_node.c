../../named/ctx_list_unlink_node.c