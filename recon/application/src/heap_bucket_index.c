../../named/heap_bucket_index.c