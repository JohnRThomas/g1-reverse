../../named/handle_dashboard_action.c