../../named/s2b.c