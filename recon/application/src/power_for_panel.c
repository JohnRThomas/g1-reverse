../../named/power_for_panel.c