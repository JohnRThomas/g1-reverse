../../named/build_str_response_frame.c