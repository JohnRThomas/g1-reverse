../../named/set_panel_voltage.c