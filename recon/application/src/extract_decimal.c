../../named/extract_decimal.c