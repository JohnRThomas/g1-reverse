../../named/format_string_to_buffer.c