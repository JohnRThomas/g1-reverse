../../named/expand_bytes_via_lut32.c