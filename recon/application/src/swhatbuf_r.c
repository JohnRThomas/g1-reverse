../../named/swhatbuf_r.c