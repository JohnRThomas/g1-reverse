../../named/click_event_dispatch_loop.c