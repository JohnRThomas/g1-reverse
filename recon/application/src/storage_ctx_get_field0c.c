../../named/storage_ctx_get_field0c.c