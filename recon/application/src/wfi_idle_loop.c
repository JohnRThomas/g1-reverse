../../named/wfi_idle_loop.c