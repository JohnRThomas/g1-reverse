../../named/flash_ops_thread.c