../../named/onoff_transition_invoke.c