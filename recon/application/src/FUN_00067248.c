../../named/FUN_00067248.c