../../named/ancs_cancel_timers.c