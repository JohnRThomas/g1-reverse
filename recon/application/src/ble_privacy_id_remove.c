../../named/ble_privacy_id_remove.c