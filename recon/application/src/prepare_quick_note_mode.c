../../named/prepare_quick_note_mode.c