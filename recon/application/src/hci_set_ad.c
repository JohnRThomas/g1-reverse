../../named/hci_set_ad.c