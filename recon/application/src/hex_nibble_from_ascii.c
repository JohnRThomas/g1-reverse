../../named/hex_nibble_from_ascii.c