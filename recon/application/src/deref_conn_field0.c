../../named/deref_conn_field0.c