../../named/d2b_decompose.c