../../named/memset_bytes.c