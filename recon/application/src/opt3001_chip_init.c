../../named/opt3001_chip_init.c