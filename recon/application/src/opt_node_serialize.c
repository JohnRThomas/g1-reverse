../../named/opt_node_serialize.c