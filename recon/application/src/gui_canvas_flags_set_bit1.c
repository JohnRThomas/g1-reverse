../../named/gui_canvas_flags_set_bit1.c