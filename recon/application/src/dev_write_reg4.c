../../named/dev_write_reg4.c