../../named/display_close_screen.c