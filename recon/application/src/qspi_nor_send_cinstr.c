../../named/qspi_nor_send_cinstr.c