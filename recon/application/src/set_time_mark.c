../../named/set_time_mark.c