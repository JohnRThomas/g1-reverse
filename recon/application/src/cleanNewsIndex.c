../../named/cleanNewsIndex.c