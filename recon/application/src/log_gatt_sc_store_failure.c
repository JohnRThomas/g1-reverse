../../named/log_gatt_sc_store_failure.c