../../named/FUN_000678d0.c