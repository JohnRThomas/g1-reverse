../../named/utf8_string_to_utf16.c