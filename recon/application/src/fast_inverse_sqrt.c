../../named/fast_inverse_sqrt.c