../../named/dequeue_ancs.c