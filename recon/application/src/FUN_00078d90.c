../../named/FUN_00078d90.c