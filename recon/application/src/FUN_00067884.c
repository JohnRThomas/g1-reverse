../../named/FUN_00067884.c