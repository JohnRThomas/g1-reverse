../../named/wdt_install_timeout.c