../../named/send_box_event_ipc.c