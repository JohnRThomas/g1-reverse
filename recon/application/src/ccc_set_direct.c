../../named/ccc_set_direct.c