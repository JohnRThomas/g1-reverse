../../named/gpio_set_fixed_pin_dt.c