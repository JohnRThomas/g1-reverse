../../named/FUN_000671d8.c