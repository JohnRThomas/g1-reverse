../../named/getStocksIndex.c