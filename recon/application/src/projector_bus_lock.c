../../named/projector_bus_lock.c