../../named/curve_table_interp_201pt.c