../../named/entropy_bt_get_entropy.c