../../named/pt_nfc_eeprom_link_init.c