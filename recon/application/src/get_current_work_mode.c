../../named/get_current_work_mode.c