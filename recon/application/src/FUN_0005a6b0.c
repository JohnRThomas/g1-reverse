../../named/FUN_0005a6b0.c