../../named/send_event.c