../../named/update_box_presence_flag.c