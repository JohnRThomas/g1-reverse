../../named/FUN_00017a04.c