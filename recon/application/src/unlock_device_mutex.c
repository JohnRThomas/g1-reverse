../../named/unlock_device_mutex.c