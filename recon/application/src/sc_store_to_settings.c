../../named/sc_store_to_settings.c