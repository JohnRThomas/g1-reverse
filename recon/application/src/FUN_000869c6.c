../../named/FUN_000869c6.c