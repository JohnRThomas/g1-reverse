../../named/dmic_stream_start.c