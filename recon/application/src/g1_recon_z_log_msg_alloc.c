../../named/g1_recon_z_log_msg_alloc.c