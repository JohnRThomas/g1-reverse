../../named/ancs_notification_forward.c