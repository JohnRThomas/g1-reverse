../../named/ancs_main.c