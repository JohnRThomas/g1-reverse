../../named/get_device_type.c