../../named/opt3007_init_ctx_setup.c