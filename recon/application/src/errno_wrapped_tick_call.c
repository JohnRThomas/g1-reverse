../../named/errno_wrapped_tick_call.c