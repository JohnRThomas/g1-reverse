../../named/ccc_find_cfg.c