../../named/update_touch_key_flag.c