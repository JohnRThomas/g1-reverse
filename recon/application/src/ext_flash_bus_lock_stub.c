../../named/ext_flash_bus_lock_stub.c