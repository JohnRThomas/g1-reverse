../../named/read_appearance.c