../../named/opt3007_chip_deinit.c