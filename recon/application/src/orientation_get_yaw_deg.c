../../named/orientation_get_yaw_deg.c