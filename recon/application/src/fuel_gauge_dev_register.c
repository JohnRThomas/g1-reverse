../../named/fuel_gauge_dev_register.c