../../named/gpio_arm_pin_interrupt.c