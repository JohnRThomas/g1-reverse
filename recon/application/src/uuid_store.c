../../named/uuid_store.c