../../named/log_msg_compute_wlen.c