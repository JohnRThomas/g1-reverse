../../named/FUN_0007eec0.c