../../named/FUN_0004ee68.c