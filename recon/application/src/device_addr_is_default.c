../../named/device_addr_is_default.c