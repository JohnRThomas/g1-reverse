../../named/bt_dev_settings_commit.c