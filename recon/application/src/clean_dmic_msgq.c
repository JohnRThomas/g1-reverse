../../named/clean_dmic_msgq.c