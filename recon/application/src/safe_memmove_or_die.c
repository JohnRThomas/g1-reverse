../../named/safe_memmove_or_die.c