../../named/display_DelayClose.c