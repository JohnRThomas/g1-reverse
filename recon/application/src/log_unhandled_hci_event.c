../../named/log_unhandled_hci_event.c