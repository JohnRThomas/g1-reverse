../../named/unpend_thread.c