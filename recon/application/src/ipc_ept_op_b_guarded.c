../../named/ipc_ept_op_b_guarded.c