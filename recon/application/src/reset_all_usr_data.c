../../named/reset_all_usr_data.c