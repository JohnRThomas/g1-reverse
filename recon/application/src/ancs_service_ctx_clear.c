../../named/ancs_service_ctx_clear.c