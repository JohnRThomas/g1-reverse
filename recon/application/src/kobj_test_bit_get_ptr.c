../../named/kobj_test_bit_get_ptr.c