../../named/gui_area_clear.c