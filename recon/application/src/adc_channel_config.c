../../named/adc_channel_config.c