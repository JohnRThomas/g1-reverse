../../named/float_to_ascii_signed_2dp.c