../../named/bond_deleted_cb.c