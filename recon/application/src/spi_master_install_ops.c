../../named/spi_master_install_ops.c