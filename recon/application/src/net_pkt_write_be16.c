../../named/net_pkt_write_be16.c