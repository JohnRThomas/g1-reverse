../../named/ipc_ept_op_a_locked_retry.c