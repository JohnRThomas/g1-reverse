../../named/device_info_set_mode.c