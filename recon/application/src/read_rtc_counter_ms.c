../../named/read_rtc_counter_ms.c