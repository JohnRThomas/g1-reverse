../../named/dev_set_threshold_and_arm.c