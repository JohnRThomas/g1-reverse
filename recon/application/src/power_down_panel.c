../../named/power_down_panel.c