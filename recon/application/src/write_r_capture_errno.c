../../named/write_r_capture_errno.c