../../named/load_icon_bitmap_expanded.c