../../named/bt_send_enabled.c