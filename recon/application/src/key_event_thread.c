../../named/key_event_thread.c