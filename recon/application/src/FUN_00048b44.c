../../named/FUN_00048b44.c