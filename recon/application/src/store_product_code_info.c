../../named/store_product_code_info.c