../../named/init_ble_work_thread.c