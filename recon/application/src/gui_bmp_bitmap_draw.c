../../named/gui_bmp_bitmap_draw.c