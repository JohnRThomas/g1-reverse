../../named/pinctrl_apply_state.c