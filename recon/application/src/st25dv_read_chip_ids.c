../../named/st25dv_read_chip_ids.c