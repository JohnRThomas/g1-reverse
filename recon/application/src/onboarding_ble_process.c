../../named/onboarding_ble_process.c