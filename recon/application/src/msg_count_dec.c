../../named/msg_count_dec.c