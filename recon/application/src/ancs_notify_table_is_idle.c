../../named/ancs_notify_table_is_idle.c