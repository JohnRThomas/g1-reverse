../../named/addr_res_enable.c