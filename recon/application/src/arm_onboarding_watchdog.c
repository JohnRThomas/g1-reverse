../../named/arm_onboarding_watchdog.c