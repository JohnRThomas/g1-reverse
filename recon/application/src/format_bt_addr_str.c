../../named/format_bt_addr_str.c