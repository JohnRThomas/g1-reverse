../../named/spawn_proxy_thread.c