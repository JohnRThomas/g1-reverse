../../named/settings_read_6byte_id28.c