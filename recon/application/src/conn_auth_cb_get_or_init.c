../../named/conn_auth_cb_get_or_init.c