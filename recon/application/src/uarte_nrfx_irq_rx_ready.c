../../named/uarte_nrfx_irq_rx_ready.c