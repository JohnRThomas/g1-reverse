../../named/SendPowerInfoToSlave.c