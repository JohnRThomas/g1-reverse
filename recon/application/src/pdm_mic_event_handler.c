../../named/pdm_mic_event_handler.c