../../named/dlist_unlink_node.c