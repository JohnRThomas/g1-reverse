../../named/get_dashboard_sum_time.c