../../named/lshift.c