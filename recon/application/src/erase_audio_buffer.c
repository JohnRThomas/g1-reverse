../../named/erase_audio_buffer.c