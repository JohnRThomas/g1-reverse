../../named/atomic_get_word.c