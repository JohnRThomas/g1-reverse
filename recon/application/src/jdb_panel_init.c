../../named/jdb_panel_init.c