../../named/process_for_new_task.c