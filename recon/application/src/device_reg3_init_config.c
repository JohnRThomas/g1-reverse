../../named/device_reg3_init_config.c