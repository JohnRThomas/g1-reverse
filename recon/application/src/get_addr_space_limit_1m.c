../../named/get_addr_space_limit_1m.c