../../named/send_touch_click_event.c