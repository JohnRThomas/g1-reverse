../../named/notification_system_init.c