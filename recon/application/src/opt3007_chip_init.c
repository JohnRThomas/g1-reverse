../../named/opt3007_chip_init.c