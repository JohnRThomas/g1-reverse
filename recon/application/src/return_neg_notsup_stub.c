../../named/return_neg_notsup_stub.c