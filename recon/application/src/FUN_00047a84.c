../../named/FUN_00047a84.c