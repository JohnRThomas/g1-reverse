../../named/parse_ncs_notification.c