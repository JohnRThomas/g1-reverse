../../named/send_data_in_ble_chunks.c