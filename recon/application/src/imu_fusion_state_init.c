../../named/imu_fusion_state_init.c