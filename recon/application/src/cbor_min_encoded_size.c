../../named/cbor_min_encoded_size.c