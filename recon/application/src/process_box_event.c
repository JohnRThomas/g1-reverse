../../named/process_box_event.c