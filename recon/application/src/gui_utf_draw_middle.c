../../named/gui_utf_draw_middle.c