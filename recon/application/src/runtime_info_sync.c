../../named/runtime_info_sync.c