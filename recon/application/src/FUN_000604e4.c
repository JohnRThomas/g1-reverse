../../named/FUN_000604e4.c