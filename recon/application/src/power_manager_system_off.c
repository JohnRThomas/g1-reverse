../../named/power_manager_system_off.c