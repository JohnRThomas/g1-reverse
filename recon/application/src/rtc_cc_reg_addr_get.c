../../named/rtc_cc_reg_addr_get.c