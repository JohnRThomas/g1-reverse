../../named/FUN_00082a42.c