../../named/driver_stop_active_timer.c