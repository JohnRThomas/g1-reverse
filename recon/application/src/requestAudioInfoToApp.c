../../named/requestAudioInfoToApp.c