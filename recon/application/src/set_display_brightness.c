../../named/set_display_brightness.c