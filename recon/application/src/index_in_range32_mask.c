../../named/index_in_range32_mask.c