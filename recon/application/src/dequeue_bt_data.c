../../named/dequeue_bt_data.c