../../named/handle_touch_single_click.c