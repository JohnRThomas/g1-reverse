../../named/set_device_sync_timestamp.c