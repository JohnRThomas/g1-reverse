../../named/log_process_thread.c