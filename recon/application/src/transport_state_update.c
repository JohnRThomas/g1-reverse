../../named/transport_state_update.c