../../named/flash_nrf_get_page_size.c