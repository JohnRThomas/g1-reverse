../../named/normalize_to_bool.c