../../named/opt3007_get_max_lux.c