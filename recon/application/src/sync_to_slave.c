../../named/sync_to_slave.c