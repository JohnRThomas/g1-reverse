../../named/lseek_r_capture_errno.c