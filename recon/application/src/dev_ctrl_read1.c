../../named/dev_ctrl_read1.c