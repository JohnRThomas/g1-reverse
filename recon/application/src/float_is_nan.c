../../named/float_is_nan.c