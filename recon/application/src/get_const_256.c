../../named/get_const_256.c