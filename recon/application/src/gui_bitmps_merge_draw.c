../../named/gui_bitmps_merge_draw.c