../../named/wlccap_record_value_len.c