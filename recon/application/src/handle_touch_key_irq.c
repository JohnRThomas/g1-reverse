../../named/handle_touch_key_irq.c