../../named/get_timestamp.c