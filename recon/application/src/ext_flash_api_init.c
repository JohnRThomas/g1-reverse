../../named/ext_flash_api_init.c