../../named/pt_comm_bind_device.c