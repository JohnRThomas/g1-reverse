../../named/verify_whitelist_json.c