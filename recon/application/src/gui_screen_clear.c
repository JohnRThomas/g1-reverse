../../named/gui_screen_clear.c