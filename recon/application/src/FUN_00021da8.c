../../named/FUN_00021da8.c