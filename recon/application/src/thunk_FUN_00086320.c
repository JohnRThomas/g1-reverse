../../named/thunk_FUN_00086320.c