../../named/fb_blit_rows_or.c