../../named/ui_QuickNote_task.c