../../named/get_device_info.c