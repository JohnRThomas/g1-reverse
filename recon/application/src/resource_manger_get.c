../../named/resource_manger_get.c