../../named/build_status_byte_packet.c