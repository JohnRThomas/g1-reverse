../../named/get_assign_channel_info.c