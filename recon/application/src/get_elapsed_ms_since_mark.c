../../named/get_elapsed_ms_since_mark.c