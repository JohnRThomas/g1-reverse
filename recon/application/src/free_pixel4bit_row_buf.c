../../named/free_pixel4bit_row_buf.c