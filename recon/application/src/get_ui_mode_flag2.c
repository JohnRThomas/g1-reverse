../../named/get_ui_mode_flag2.c