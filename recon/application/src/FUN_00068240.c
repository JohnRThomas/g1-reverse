../../named/FUN_00068240.c