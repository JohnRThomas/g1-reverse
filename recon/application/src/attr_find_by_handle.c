../../named/attr_find_by_handle.c