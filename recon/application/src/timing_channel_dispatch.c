../../named/timing_channel_dispatch.c