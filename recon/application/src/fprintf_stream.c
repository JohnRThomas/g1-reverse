../../named/fprintf_stream.c