../../named/ctz32_normalize_inplace.c