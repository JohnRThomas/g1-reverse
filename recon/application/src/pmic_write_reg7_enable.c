../../named/pmic_write_reg7_enable.c