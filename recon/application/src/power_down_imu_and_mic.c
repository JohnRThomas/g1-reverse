../../named/power_down_imu_and_mic.c