../../named/FUN_00068298.c