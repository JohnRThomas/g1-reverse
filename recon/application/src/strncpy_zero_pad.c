../../named/strncpy_zero_pad.c