../../named/itoa_signed_exponent.c