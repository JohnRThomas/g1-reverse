../../named/clear_event_registrations.c