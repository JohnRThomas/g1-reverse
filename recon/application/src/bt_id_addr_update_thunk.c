../../named/bt_id_addr_update_thunk.c