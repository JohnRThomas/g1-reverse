../../named/get_message_entry.c