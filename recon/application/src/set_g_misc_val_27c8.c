../../named/set_g_misc_val_27c8.c