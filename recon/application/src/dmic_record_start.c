../../named/dmic_record_start.c