../../named/clock_control_nrf_init.c