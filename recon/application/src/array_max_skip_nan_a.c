../../named/array_max_skip_nan_a.c