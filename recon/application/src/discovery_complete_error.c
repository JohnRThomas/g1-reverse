../../named/discovery_complete_error.c