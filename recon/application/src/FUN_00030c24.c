../../named/FUN_00030c24.c