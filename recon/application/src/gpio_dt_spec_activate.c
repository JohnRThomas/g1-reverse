../../named/gpio_dt_spec_activate.c