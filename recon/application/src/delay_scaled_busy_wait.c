../../named/delay_scaled_busy_wait.c