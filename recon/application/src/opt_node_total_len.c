../../named/opt_node_total_len.c