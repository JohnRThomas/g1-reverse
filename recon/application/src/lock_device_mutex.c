../../named/lock_device_mutex.c