../../named/get_localized_string_ptr.c