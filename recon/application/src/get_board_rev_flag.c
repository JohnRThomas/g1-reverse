../../named/get_board_rev_flag.c