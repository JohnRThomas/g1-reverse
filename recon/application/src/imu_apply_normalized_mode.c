../../named/imu_apply_normalized_mode.c