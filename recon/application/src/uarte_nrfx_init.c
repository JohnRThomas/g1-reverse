../../named/uarte_nrfx_init.c