../../named/ctx_list_unlink_by_key16.c