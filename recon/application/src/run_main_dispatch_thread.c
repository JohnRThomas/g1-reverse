../../named/run_main_dispatch_thread.c