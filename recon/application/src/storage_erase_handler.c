../../named/storage_erase_handler.c