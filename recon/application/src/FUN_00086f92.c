../../named/FUN_00086f92.c