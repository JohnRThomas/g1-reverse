../../named/check_device_readiness.c