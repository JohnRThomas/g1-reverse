../../named/opt_record_bind_value.c