../../named/st25dv_read_reg_pair.c